## map_spoof/Kconfig
```kconfig
menu "reboot"

config MAP_SPOOF
	bool "Basic map spoof support"
	default y
	help
	  Enables map spoofing by zeroing certain fields.

endmenu
```
